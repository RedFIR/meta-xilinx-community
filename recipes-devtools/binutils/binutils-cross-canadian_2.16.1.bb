require binutils_${PV}.bb
require recipes-devtools/binutils/binutils-cross-canadian.inc
PR = "r0"
